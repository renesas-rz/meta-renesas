INSANE_SKIP_${PN} += "arch"
RDEPENDS_${PN} += "gawk"
