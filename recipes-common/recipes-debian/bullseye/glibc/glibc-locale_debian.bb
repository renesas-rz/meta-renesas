require recipes-common/recipes-debian/bullseye/glibc/glibc-locale.inc
require recipes-common/recipes-debian/bullseye/sources/glibc.inc
