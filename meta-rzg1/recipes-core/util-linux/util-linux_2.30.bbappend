
SHARED_EXTRA_OECONF_append += " \
                       --disable-schedutils \
"
