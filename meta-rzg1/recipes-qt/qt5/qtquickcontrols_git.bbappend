#Revision to update qt5.6.3
require qt5.6.3_git.inc
SRCREV = "b66f6b05c5f8024ddd9f8c46f33ccb618323999e"

LIC_FILES_CHKSUM = " \
    file://LICENSE.LGPLv3;md5=a37e6cd7102174853307e03e6edc5f30 \
    file://LICENSE.GPLv3;md5=88e2b9117e6be406b5ed6ee4ca99a705 \
    file://LICENSE.GPLv2;md5=c96076271561b0e3785dad260634eaa8 \
    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e \
"
