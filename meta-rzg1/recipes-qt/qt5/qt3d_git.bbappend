#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "d3889211dc245d44dab25dcc9fbbc4b57e92ac33"

LIC_FILES_CHKSUM = " \
    file://LICENSE.LGPLv3;md5=8211fde12cc8a4e2477602f5953f5b71 \
    file://LICENSE.GPLv3;md5=88e2b9117e6be406b5ed6ee4ca99a705 \
    file://LICENSE.GPL;md5=c96076271561b0e3785dad260634eaa8 \
"
