#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "e93c73c0aa15cd973e008a04a70a7c69719ad244"

LIC_FILES_CHKSUM = " \
    file://LICENSE.LGPLv3;md5=a37e6cd7102174853307e03e6edc5f30 \
    file://LICENSE.GPLv3;md5=88e2b9117e6be406b5ed6ee4ca99a705 \
    file://LICENSE.FDL;md5=6d9f2a9af4c8b8c3c769f6cc1b6aaf7e \
"
