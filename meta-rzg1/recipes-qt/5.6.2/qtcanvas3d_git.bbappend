#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "85fe2daab5ed14655b456df8821c9f5f606fdc12"
