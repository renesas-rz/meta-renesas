#Revision for updating qt5.6.2
require qt5.6.2_git.inc
SRCREV = "b4ada3f0d8feed7dbff22aa780d38ab126020ac6"

LIC_FILES_CHKSUM = " \
    file://LICENSE.LGPLv21;md5=fb91571854638f10b2e5f36562661a5a \
    file://LICENSE.LGPLv3;md5=a909b94c1c9674b2aa15ff03a86f518a \
    file://LICENSE.GPLv3;md5=88e2b9117e6be406b5ed6ee4ca99a705 \
"
