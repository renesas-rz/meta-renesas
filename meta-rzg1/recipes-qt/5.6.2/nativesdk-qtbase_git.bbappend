#Revision for qt5.6.2
require qt5.6.2_git.inc
SRCREV = "b4ada3f0d8feed7dbff22aa780d38ab126020ac6"
