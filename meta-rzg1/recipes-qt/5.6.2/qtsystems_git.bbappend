#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "ffcf1ff783827171c3fb911cc90b2d0ecb2931af"
