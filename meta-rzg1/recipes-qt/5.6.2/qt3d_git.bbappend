#Revision to update qt5.6.2
PV = "5.6.3+git${SRCPV}"
SRCREV = "0eac16fbda846c951f9b3887199e72b66f5aacd7"

LIC_FILES_CHKSUM = " \
    file://LICENSE.LGPLv3;md5=e0459b45c5c4840b353141a8bbed91f0 \
    file://LICENSE.GPLv3;md5=88e2b9117e6be406b5ed6ee4ca99a705 \
"
