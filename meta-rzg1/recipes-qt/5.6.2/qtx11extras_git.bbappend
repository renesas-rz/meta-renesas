#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "df10edcfae328f397c99192b322268c9e96f6dab"
