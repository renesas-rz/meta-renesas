#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "a9e5e09f156b09c7f65e0b57fe191d71f9c1aa3e"
