#Revision for qt5.6.2
require qt5.6.2_git.inc
SRCREV = "2a143bf81b2ffb3bd7a5f47cf719e6ed347bf383"
