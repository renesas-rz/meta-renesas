#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "225e1740fec4559bf8d66d915ddd06b9d4f48119"
