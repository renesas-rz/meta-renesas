#Revision to update qt5.6.2
require qt5.6.2_git.inc
SRCREV = "e93c73c0aa15cd973e008a04a70a7c69719ad244"
