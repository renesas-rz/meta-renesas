#Revision for qt5.6.2
require qt5.6.2_git.inc
SRCREV = "b35917bcb44d7f200af0f4ac68a126fa0aa8d93d"
