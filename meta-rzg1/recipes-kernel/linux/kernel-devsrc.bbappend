RDEPENDS_${PN} += "python"
