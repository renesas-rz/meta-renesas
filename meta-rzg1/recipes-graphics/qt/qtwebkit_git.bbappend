
DEPENDS_remove = "leveldb"