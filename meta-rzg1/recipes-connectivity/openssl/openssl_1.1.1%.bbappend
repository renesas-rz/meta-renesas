# openssl-bin is required by new ca-certificates recipe
FILES_${PN}-bin += "${bindir}/"