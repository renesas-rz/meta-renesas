BBCLASSEXTEND = "${@'native nativesdk' if 'Buster' in '${MACHINE_FEATURES}' else ''}"
