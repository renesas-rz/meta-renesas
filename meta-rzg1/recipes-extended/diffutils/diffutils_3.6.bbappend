# Prevent error with getopt_long
EXTRA_OECONF += "gl_cv_func_getopt_gnu=yes"
