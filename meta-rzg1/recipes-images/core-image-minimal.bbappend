include core-image-renesas-base-nommp.inc
#include core-image-renesas-base.inc
