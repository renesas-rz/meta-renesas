require recipes-core/glibc/glibc-locale.inc
require sources/glibc.inc
