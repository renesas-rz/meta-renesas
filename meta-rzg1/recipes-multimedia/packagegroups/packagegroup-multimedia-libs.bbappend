DEPENDS_remove = "vspmif-user-module"
RDEPENDS_packagegroup-multimedia-libs_remove= " \
    vspmif-user-module \
"
