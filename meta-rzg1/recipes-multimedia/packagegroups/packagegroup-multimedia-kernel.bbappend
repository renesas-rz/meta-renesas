DEPENDS_remove = "kernel-module-vspmif"
RDEPENDS_packagegroup-multimedia-kernel-modules_remove = " \
    kernel-module-vspmif \
"

