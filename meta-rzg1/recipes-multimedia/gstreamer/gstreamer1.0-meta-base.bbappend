RDEPENDS_gstreamer1.0-meta-video_remove = "gstreamer1.0-plugins-good-avi"
RDEPENDS_gstreamer1.0-meta-audio_remove = "gstreamer1.0-plugins-good-wavparse"
