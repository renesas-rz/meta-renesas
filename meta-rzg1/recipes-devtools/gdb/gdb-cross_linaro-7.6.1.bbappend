require gdb-linaro-7.6.1-append.inc


