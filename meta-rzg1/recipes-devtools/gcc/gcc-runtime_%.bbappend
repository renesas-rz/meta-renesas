FILES_libstdc++-dev += " \
    ${libdir}/libstdc++*.la \
"

FILES_libstdc++-staticdev += " \
    ${libdir}/libstdc++*.a \
"
