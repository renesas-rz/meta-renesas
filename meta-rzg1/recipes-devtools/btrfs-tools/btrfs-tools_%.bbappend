# Fix rebuild error happens sometimes
# refer to  https://git.yoctoproject.org/cgit/cgit.cgi/poky/commit/?id=fb50eb6ef0b162916a848b52de91022e28a64e52
CLEANBROKEN = "1"
