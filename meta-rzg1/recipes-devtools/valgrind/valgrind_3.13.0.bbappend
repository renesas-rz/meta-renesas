FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI += "file://0001-Fix-error-undefined-reference-to-__fpclassify.patch"
