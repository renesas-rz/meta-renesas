FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += " \
	file://0001-fix-issue-on-test-case-RT-pip_stress.patch \
"
