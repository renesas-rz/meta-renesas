INSANE_SKIP_${PN} += "arch"
