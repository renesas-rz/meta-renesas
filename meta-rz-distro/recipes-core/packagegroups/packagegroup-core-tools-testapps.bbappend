RDEPENDS:${PN}:append = " \
	connman-wait-online \
"

RDEPENDS:${PN}:remove = "ltp"
