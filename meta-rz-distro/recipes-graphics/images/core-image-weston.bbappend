require include/rz-distro-common.inc
