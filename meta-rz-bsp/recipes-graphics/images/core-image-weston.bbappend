require include/core-image-renesas-mmp.inc
