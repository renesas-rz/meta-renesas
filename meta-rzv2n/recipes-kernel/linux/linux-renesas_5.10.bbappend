DESCRIPTION = "Linux kernel for the RZ/V2N based board"

COMPATIBLE_MACHINE_rzv2n = "(rzv2n-dev|rzv2n-evk)"

BRANCH = "rzv2n-5.10-cip17"
SRCREV = "e619ed8241f998b0e7f6e70feab606272e27655a"

LINUX_VERSION = "5.10.145-cip17"
