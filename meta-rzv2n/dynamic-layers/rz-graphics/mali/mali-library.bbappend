COMPATIBLE_MACHINE = "(r9a09g056)"
