COMPATIBLE_MACHINE_append = "(rzv2m|rzv2ma)"

BRANCH_rzv2m = "v2m/rz-5.10-cip29"
SRCREV_rzv2m = "48630e508f6d8dc1a55998db7c4da1d057733082"

BRANCH_rzv2ma = "v2ma/rz-5.10-cip29"
SRCREV_rzv2ma = "6284f9602f1db4b088a7c74cdbd62191114f53e2"
