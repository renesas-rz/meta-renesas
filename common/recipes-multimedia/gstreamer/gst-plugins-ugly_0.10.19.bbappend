FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

require gst-plugins-private-libs.inc
