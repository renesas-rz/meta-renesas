SUMMARY = "Docker package groups"
LICENSE = "MIT"

inherit packagegroup
