FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}/:"

SRC_URI += " \
	file://0001-connman-wait-online.service-WA-to-remove-previous-de.patch \
"
