#Revision to update qt5.6.3
require qt5.6.3_git.inc
SRCREV = "8bbd832997841927e0d8a433f4ec20c82cdea203"

LIC_FILES_CHKSUM = " \
    file://LICENSE.LGPLv3;md5=e0459b45c5c4840b353141a8bbed91f0 \
    file://LICENSE.GPLv2;md5=c96076271561b0e3785dad260634eaa8 \
    file://LICENSE.GPLv3;md5=88e2b9117e6be406b5ed6ee4ca99a705 \
"
