INSANE_SKIP_${PN} += "installed-vs-shipped"
