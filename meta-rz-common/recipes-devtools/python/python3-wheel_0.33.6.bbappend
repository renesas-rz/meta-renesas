# Replace the branch name "master" -> "main" due to change on upstream repo
SRC_URI = "git://github.com/pypa/wheel.git;branch=main;protocol=https"
