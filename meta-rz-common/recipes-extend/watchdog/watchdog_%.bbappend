FILESEXTRAPATHS_append := "${THISDIR}/${PN}/:"
SYSTEMD_AUTO_ENABLE = "enable"
