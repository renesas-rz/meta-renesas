require recipes-debian/bullseye/glibc/glibc-locale.inc
require recipes-debian/bullseye/sources/glibc.inc
