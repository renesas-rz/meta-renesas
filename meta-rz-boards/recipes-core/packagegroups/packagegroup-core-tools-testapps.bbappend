RDEPENDS:${PN}:append = " \
	connman-wait-online \
"
